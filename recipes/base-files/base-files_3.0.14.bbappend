FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

do_install_append () {
#HM specific

}

